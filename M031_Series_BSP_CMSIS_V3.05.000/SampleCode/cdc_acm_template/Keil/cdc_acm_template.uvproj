# Keil uVision project cdc_acm_template.uvproj, settings and files
target cdc_acm_template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: cdc_acm_template
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\..\..\..\CherryUSB\core;..\..\..\..\CherryUSB\class\cdc;..\..\..\..\CherryUSB\common;..\..\..\..\rt-thread\include;..\..\cdc_acm_template
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: uart.c clk.c
  group User
    ../: main.c
  group board
    ../: board.c rtconfig.h usb_config.h
  group rtthread
    ../../../../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c signal.c slab.c thread.c timer.c
  group rtthread/libcpu
    ../../../../rt-thread/libcpu/arm/common/: div0.c showmem.c
    ../../../../rt-thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group CherryUSB/core
    ../../../../CherryUSB/core/: usbd_core.c
  group CherryUSB/class
    ../../../../CherryUSB/class/cdc/: usbd_cdc.c
  group CherryUSB/port
    ../: usb_dc_ll.c usb_dc_usbfs.c
