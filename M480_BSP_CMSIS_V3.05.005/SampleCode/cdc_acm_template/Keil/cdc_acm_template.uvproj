# Keil uVision project cdc_acm_template.uvproj, settings and files
target cdc_acm_template (6190000::V6.19::ARMCLANG)
  device: M483KGCAE2A Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x3FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: cdc_acm_template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=5
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\Library\StdDriver\inc;..\..\..\..\..\CherryUSB\core;..\..\..\..\..\CherryUSB\class\cdc;..\..\..\..\..\CherryUSB\common;..\..\..\..\rt-thread\include;..\..\cdc_acm_template
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../../Library/StdDriver/src/: uart.c sys.c clk.c
  group User
    ../: main.c
  group board
    ../: board.c rtconfig.h usb_config.h
  group rtthread
    ../../../../rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c signal.c slab.c thread.c timer.c
  group rtthread/libcpu
    ../../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group CherryUSB/core
    ../../../../../CherryUSB/core/: usbd_core.c
  group CherryUSB/class
    ../../../../../CherryUSB/class/cdc/: usbd_cdc.c
  group CherryUSB/port
    ../: usb_dc_ll.c usb_dc_usbfs.c
